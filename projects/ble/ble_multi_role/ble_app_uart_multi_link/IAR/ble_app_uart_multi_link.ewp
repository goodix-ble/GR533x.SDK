# IAR project ble_app_uart_multi_link.ewp, settings and files
configuration ble_app_uart_multi_link (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\Src\platform; ..\Src\user; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\drivers_ext\gr55xx; ..\..\..\..\..\components\drivers_ext\st7735; ..\..\..\..\..\components\drivers_ext\vs1005; ..\..\..\..\..\components\libraries\app_alarm; ..\..\..\..\..\components\libraries\app_assert; ..\..\..\..\..\components\libraries\app_error; ..\..\..\..\..\components\libraries\app_key; ..\..\..\..\..\components\libraries\app_log; ..\..\..\..\..\components\libraries\app_queue; ..\..\..\..\..\components\libraries\app_timer; ..\..\..\..\..\components\libraries\at_cmd; ..\..\..\..\..\components\libraries\dfu_master; ..\..\..\..\..\components\libraries\dfu_port; ..\..\..\..\..\components\libraries\gui; ..\..\..\..\..\components\libraries\gui\gui_config; ..\..\..\..\..\components\libraries\hal_flash; ..\..\..\..\..\components\libraries\hci_uart; ..\..\..\..\..\components\libraries\pmu_calibration; ..\..\..\..\..\components\libraries\ring_buffer; ..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\components\libraries\utility; ..\..\..\..\..\components\patch\ind; ..\..\..\..\..\components\profiles\ams_c; ..\..\..\..\..\components\profiles\ancs_c; ..\..\..\..\..\components\profiles\ans; ..\..\..\..\..\components\profiles\ans_c; ..\..\..\..\..\components\profiles\bas; ..\..\..\..\..\components\profiles\bas_c; ..\..\..\..\..\components\profiles\bcs; ..\..\..\..\..\components\profiles\bps; ..\..\..\..\..\components\profiles\common; ..\..\..\..\..\components\profiles\cscs; ..\..\..\..\..\components\profiles\cts; ..\..\..\..\..\components\profiles\cts_c; ..\..\..\..\..\components\profiles\dis; ..\..\..\..\..\components\profiles\dis_c; ..\..\..\..\..\components\profiles\gls; ..\..\..\..\..\components\profiles\gus; ..\..\..\..\..\components\profiles\gus_c; ..\..\..\..\..\components\profiles\hids; ..\..\..\..\..\components\profiles\hrrcps; ..\..\..\..\..\components\profiles\hrs; ..\..\..\..\..\components\profiles\hrs_c; ..\..\..\..\..\components\profiles\hts; ..\..\..\..\..\components\profiles\ias; ..\..\..\..\..\components\profiles\lls; ..\..\..\..\..\components\profiles\ndcs; ..\..\..\..\..\components\profiles\otas; ..\..\..\..\..\components\profiles\otas_c; ..\..\..\..\..\components\profiles\pass; ..\..\..\..\..\components\profiles\pass_c; ..\..\..\..\..\components\profiles\pcs; ..\..\..\..\..\components\profiles\rscs; ..\..\..\..\..\components\profiles\rscs_c; ..\..\..\..\..\components\profiles\rtus; ..\..\..\..\..\components\profiles\sample; ..\..\..\..\..\components\profiles\ths; ..\..\..\..\..\components\profiles\ths_c; ..\..\..\..\..\components\profiles\thscps; ..\..\..\..\..\components\profiles\tps; ..\..\..\..\..\components\profiles\wechat; ..\..\..\..\..\components\sdk\; ..\..\..\..\..\drivers\inc; ..\..\..\..\..\external\freertos\include; ..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\components\libraries\ble\common; ..\..\..\..\..\components\libraries\ble\ble_advertising; ..\..\..\..\..\components\libraries\ble\ble_connect; ..\..\..\..\..\components\profiles\mlmr; ..\..\..\..\..\components\profiles\mlmr_c; ..\Src\config; ..\..\..\..\..\platform\include; ..\..\..\..\..\platform\soc\include; ..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include; ..\..\..\..\..\platform\soc\linker\keil; ..\Src\config; ..\..\..\..\..\drivers\inc\hal; ..\..\..\..\..\components\app_drivers\inc; ..\..\..\..\..\platform\boards
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble_app_uart_multi_link.bin
  prebuild: GR5xxx_make_icf.bat
  ILINK.IlinkOutputFile: ble_app_uart_multi_link.out
  ILINK.IlinkIcfFile: gr5332.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\platform\soc\linker\iar\rom_symbol_iar.txt
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\platform\soc\linker\iar\ble_sdk.a; ..\..\..\..\..\components\mesh\lib\iar\mesh.a; ..\..\..\..\..\components\libraries\app_crypto\iar\app_crypto.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/iar/: startup_gr55xx.s
  group gr_arch
    ../../../../../platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_app_drivers
    ../../../../../drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_uart_dma.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_error/: app_error.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/sdk/: ble.c
  group gr_profiles
    ../../../../../components/profiles/common/: ble_prf_utils.c
    ../../../../../components/profiles/mlmr/: mlmr.c
    ../../../../../components/profiles/mlmr_c/: mlmr_c.c
  group external
    ../../../../../external/segger_rtt/: SEGGER_RTT.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c transport_scheduler.c
    ../Src/config/: custom_config.h
