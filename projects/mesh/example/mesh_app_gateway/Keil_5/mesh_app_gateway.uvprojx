# Keil uVision project mesh_app_gateway.uvprojx, settings and files
target GRxx_Soc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: mesh_app_gateway
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Src\user;..\Src\platform;..\Src\config;..\Src\user_callback;..\Src\config;..\..\..\..\..\components\boards;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\ble\ble_task;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hal_flash\vflash;..\..\..\..\..\components\libraries\hal_flash\xflash;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\nothing;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\sdk;..\..\..\..\..\components\sdk\ble_sdk_api;..\..\..\..\..\components\sdk\sys_sdk_api;..\..\..\..\..\components\app_drivers\inc;..\..\..\..\..\components\mesh\mesh_api;..\..\..\..\..\components\mesh\models;..\..\..\..\..\components\mesh\models\Vendor\simple_onoff\include;..\..\..\..\..\drivers\inc;..\..\..\..\..\drivers\inc\hal;..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\..\..\platform\boards;..\..\..\..\..\platform\include;..\..\..\..\..\platform\soc\include;..\..\..\..\..\platform\soc\linker\keil
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\..\..\platform\soc\linker\keil\flash_scatter_common.sct
  link misc: ..\..\..\..\..\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../../../platform/soc/common/: gr_interrupt.c gr_platform.c gr_system.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../../../platform/soc/linker/keil/: ble_sdk.lib
  group gr_mesh_lib
    ../../../../../components/mesh/lib/keil/: mesh.lib
  group gr_app_drivers
    ../../../../../drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_uart_dma.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_error/: app_error.c cortex_backtrace.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/libraries/fault_trace/: fault_trace.c
    ../../../../../components/sdk/: ble.c
    ../../../../../components/libraries/sensorsim/: sensorsim.c
  group gr_profiles
    ../../../../../components/profiles/common/: ble_prf_utils.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c user_uart_cmd.c user_bat_s.c bat_s.c user_mesh_callback.c user_auto_prov.c user_model_client.c
  group user_config
    ../Src/config/: custom_config.h mesh_stack_config.h
