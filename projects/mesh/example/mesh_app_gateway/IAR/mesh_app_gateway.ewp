# IAR project mesh_app_gateway.ewp, settings and files
configuration mesh_app_gateway (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\Src\user; ..\Src\platform; ..\Src\config; ..\Src\user_callback; ..\Src\config; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\libraries\app_timer; ..\..\..\..\..\components\libraries\ble\ble_task; ..\..\..\..\..\components\libraries\hal_flash; ..\..\..\..\..\components\libraries\hal_flash\vflash; ..\..\..\..\..\components\libraries\hal_flash\xflash; ..\..\..\..\..\components\libraries\log; ..\..\..\..\..\components\libraries\nothing; ..\..\..\..\..\components\libraries\utility; ..\..\..\..\..\components\libraries\app_key; ..\..\..\..\..\components\libraries\app_log; ..\..\..\..\..\components\libraries\ring_buffer; ..\..\..\..\..\components\libraries\app_error; ..\..\..\..\..\components\libraries\app_assert; ..\..\..\..\..\components\libraries\pmu_calibration; ..\..\..\..\..\components\libraries\fault_trace; ..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\components\profiles\common; ..\..\..\..\..\components\sdk; ..\..\..\..\..\components\sdk\ble_sdk_api; ..\..\..\..\..\components\sdk\sys_sdk_api; ..\..\..\..\..\components\app_drivers\inc; ..\..\..\..\..\components\mesh\mesh_api; ..\..\..\..\..\components\mesh\models; ..\..\..\..\..\components\mesh\models\Vendor\simple_onoff\include; ..\..\..\..\..\drivers\inc; ..\..\..\..\..\drivers\inc\hal; ..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include; ..\..\..\..\..\platform\boards; ..\..\..\..\..\platform\include; ..\..\..\..\..\platform\soc\include; ..\..\..\..\..\platform\soc\linker\keil
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mesh_app_gateway.bin
  prebuild: GR5xxx_make_icf.bat
  ILINK.IlinkOutputFile: mesh_app_gateway.out
  ILINK.IlinkIcfFile: gr5332.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\..\..\platform\soc\linker\iar\rom_symbol_iar.txt
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\platform\soc\linker\iar\ble_sdk.a; ..\..\..\..\..\components\mesh\lib\iar\mesh.a; ..\..\..\..\..\components\libraries\app_crypto\iar\app_crypto.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/iar/: startup_gr55xx.s
  group gr_arch
    ../../../../../platform/soc/common/: gr_interrupt.c gr_platform.c gr_system.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_app_drivers
    ../../../../../drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_uart_dma.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_error/: app_error.c cortex_backtrace.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/libraries/fault_trace/: fault_trace.c
    ../../../../../components/sdk/: ble.c
    ../../../../../components/libraries/sensorsim/: sensorsim.c
  group gr_profiles
    ../../../../../components/profiles/common/: ble_prf_utils.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c user_uart_cmd.c user_bat_s.c bat_s.c user_mesh_callback.c user_auto_prov.c user_model_client.c
  group user_config
    ../Src/config/: custom_config.h mesh_stack_config.h
