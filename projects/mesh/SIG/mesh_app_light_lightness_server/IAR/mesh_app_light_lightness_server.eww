<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mesh_app_light_lightness_server.ewp</path>
  </project>
  <batchBuild/>
</workspace>
